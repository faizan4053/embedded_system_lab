# Keil uVision project relay_buzzer.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E054 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: relay_buzzer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 relay_buzzer.c
