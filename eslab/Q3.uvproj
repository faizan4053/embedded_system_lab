# Keil uVision project Q3.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78C054 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(24000000)
  output: Q3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Q3.c
