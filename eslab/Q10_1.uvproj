# Keil uVision project Q10_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E054 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: Q10_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 keypad.h delay.h 7segment.c
